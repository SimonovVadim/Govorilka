# IAR project GOVORILKA_NEW.ewp, settings and files
configuration GOVORILKA_NEW (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F100xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Modules\FatFs; C:\Users\123\Desktop\GOVORILKA_NEW\GOVORILKA_NEW\Modules\FatFs; C:\Users\123\Desktop\GOVORILKA_NEW\GOVORILKA_NEW; C:\Users\123\Desktop\GOVORILKA_NEW\GOVORILKA_NEW\Modules\LCD; C:\Users\123\Desktop\GOVORILKA_NEW\GOVORILKA_NEW\Modules\FatFs; C:\Users\123\Desktop\GOVORILKA_NEW\GOVORILKA_NEW\Modules\C1101; C:\Users\123\Desktop\GOVORILKA_NEW\GOVORILKA_NEW\Modules\Delay
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: GOVORILKA_NEW.out
  ILINK.IlinkIcfFile: stm32f100xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f100xb.s
  group Application/User
    ../: App.c App.h write.c
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Modules/Delay
    ../Modules/Delay/: Delay.c
  group Modules/FatFs
    ../Modules/FatFs/: diskio.h fatfs_diskio_sdcard_spi.c ff.c ff.h ffconf.h integer.h
  group Modules/LCD
    ../Modules/LCD/: font7x15.h func.c func.h
  group Modules/Radio
    ../Modules/C1101/: c1101.c C1101.h
